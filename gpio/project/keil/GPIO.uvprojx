# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\project;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group lib
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
