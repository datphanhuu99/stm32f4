# Keil uVision project blinkLed.uvprojx, settings and files
target blinkLed (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinkLed +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc; C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Include; C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c
  group Drivers/CMSIS
    C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
software components: CMSIS:CORE 4.1.0
